# Keil uVision project httpServer.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: httpServer
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Network:CORE 7.1.0, Network:Interface:SLIP 7.1.0, Network:Service:Web Server Compact 7.1.0, Network:Socket:TCP 7.1.0, CMSIS Driver:USART 2.0, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0
