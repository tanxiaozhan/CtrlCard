# Keil uVision project Ctrlcard.uvprojx, settings and files
target ControlCard (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: debugTest
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\debugTest;.\Lib\inc;.\RTE\Device\STM32F103VE;.\Common;.\temp;.\RTE\Network;.\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    Web/: Web.c
    ./Source/: Board_LED.c esp8266.c HTTP_Server_CGI.c main.c Port_08_12.c Usart1.c LED_Display.c Flash_SPI.c rtc.c
  group Web
    ./Web/: index.htm llblue.jpg content.cgi screenSet.cgi areaEdit.cgi areaSet.cgi header.inc auth.gif content.gif info.gif pabb.gif power.gif scan.gif screenNo.gif screenSet.gif setTime.gif password.cgi edit.cgi chkScreen.jpg auth.cgi setTime.cgi power.cgi logo.png back.png home.png footer.inc chkScreen.cgi info.cgi scan.cgi areaEdit1.cgi areaSet1.cgi auth1.cgi chkScreen1.cgi content1.cgi edit1.cgi info1.cgi password1.cgi power1.cgi scan1.cgi screenSet1.cgi setTime1.cgi index1.htm header1.inc
  group Doc
    ./Doc/: scan_type.jpg readme.txt http_cgi_par.txt RTC_txt.txt extern_flash_address.txt
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Network:CORE 7.1.0, Network:Interface:SLIP 7.1.0, Network:Service:Web Server Compact 7.1.0, Network:Socket:TCP 7.1.0, CMSIS Driver:USART 2.0, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
