# Keil uVision project CtrlCard.uvprojx, settings and files
target Target (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CtrlCard
  c flags: Optim=1 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source
    ./Source/: main.c HTTP_Server_CGI.c Flash_SPI.c LED_Display.c Port_08_12.c rtc.c esp8266.c usartX.c Board_LED.c
    Web/: Web.c
  group Web
    ./Web/: areaEdit.cgi areaSet.cgi auth.cgi chkScreen.cgi content.cgi edit.cgi info.cgi password.cgi power.cgi scan.cgi screenSet.cgi setTime.cgi index.htm auth.gif content.gif info.gif pabb.gif power.gif scan.gif screenNo.gif screenSet.gif setTime.gif llblue.jpg footer.inc header.inc logo.png home.png back.png chkScreen.jpg
  group Doc
    ./Doc/: extern_flash_address.txt http_cgi_par.txt readme.txt RTC_txt.txt scan_type.jpg
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Network:CORE 7.1.0, Network:Interface:SLIP 7.1.0, Network:Service:Web Server Compact 7.1.0, Network:Socket:TCP 7.1.0, CMSIS Driver:USART 2.0, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
