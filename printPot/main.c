#include <stdio.h>
#include <stdlib.h>

#define fontHeigth 16
/* run this program using the console pauser or add your own getch, system("pause") or input loop */

int main(int argc, char *argv[]) {
	unsigned int dot[fontHeigth*3]={
	//0x00,0x00,0x00,0x78,0x0C,0x0C,0x0C,0x7E,0x0C,0x0C,0x0C,0x0C,0x00,0x00,0x00,0x00	//"f" 
	0xff,0xff,0xff,0xc3,0x99,0x99,0xf9,0xe3,0xf9,0x99,0x99,0xc3,0xff,0xff,0xff,0xff,
	0xff,0x00,0xfe,0xfe,0xc0,0xce,0xd6,0xda,0xce,0xd6,0xda,0xde,0xde,0xde,0xde,0xde,
	0xff,0x0f,0xff,0xff,0x0f,0x7f,0xbf,0xdf,0x7f,0xbf,0xdf,0xff,0xff,0xff,0xdf,0xef
	//0xff,0x03,0xff,0xff,0x07,0x77,0xb7,0xd7,0x77,0xb7,0xd7,0xf7,0xf7,0xf7,0xf7,0xef  
	//0xff,0x00,0x7f,0x7f,0x03,0x73,0x6b,0x5b,0x73,0x6b,0x5b,0x7b,0x7b,0x7b,0x7b,0xfb,
	//0xff,0x87,0xff,0xff,0xe7,0xef,0xef,0xef,0xef,0xef,0xef,0xef,0xef,0xef,0xef,0xf7	
	};
	int i,j;
	int scan;
	for(i=0;i<fontHeigth;i++){
		scan=0x80;
		for(j=0;j<8;j++){
			if( !(dot[i] & scan ) )
				printf("*");
			else
				printf(" ");

			scan >>=  1 ;
		} 
		printf("\n");
	}
	printf("\n");

	for(i=16;i<32;i++){
		scan=0x80;
		for(j=0;j<8;j++){
			if( !(dot[i] & scan ) )
				printf("*");
			else
				printf(" ");

			scan >>=  1 ;
		}
		scan=0x80;
		for(j=0;j<8;j++){
			if(!(dot[i+16] & scan))
				printf("*");
			else
				printf(" ");
			
			scan>>=1;
		}
		printf("\n");
	}

	
	
	
	return 0;
}
